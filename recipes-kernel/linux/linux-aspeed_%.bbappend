# Onyx custom kernel configurations and Device Tree (DTS) modifications

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

# Example: Add your kernel patches or custom DTS files below
# SRC_URI += "file://0001-add-onyx-i2c-eeprom-dts.patch"
